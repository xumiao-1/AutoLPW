# Keil uVision project auto.uvprojx, settings and files
target AUTO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L151D-EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\userapp\usr_function;..\userapp\avr;..\sensor;..\network;..\Common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group User
    ../: stm32l1xx_it.c
    ../userapp/avr/: com.c function.c hal_avr.c stm32_timer.c tat.c
    ../sensor/: iic_driver.c flash.c sensor_tmp102.c sensor_gpio.c
    ../network/: net_p2p.c app_layer.c net_layer.c
    ../userapp/usr_function/: com_buf.c flash_funcs.c main.c mydef.c startup.c user_function.c bat_monitor.c
  group StdPeriph_Driver
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_gpio.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_rcc.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_pwr.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_rtc.c misc.c
  group CMSIS
    ../: system_stm32l1xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
software components: CMSIS:CORE 4.3.0
